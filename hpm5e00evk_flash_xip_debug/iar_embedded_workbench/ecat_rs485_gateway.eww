<?xml version="1.0" encoding="UTF-8"?>
<workspace>
<project>
<path>$WS_DIR$\ecat_rs485_gateway.ewp</path>
</project>
<batchBuild />
</workspace>